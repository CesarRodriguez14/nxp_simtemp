IMAGE_INSTALL:append = " nxp-simtemp-cli"
